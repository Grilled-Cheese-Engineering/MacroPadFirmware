## boards/shields/gce3x3macro/Kconfig.defconfig
```kconfig
if SHIELD_GCE3X3MACRO

config ZMK_KEYBOARD_NAME
    default "3x3macro"

config ZMK_SPLIT
    default n

endif # SHIELD_GCE3X3MACRO
```
